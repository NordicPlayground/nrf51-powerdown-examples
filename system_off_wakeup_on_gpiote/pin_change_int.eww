<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\iar\pin_change_int_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10040\iar\pin_change_int_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\iar\pin_change_int_pca10036.ewp</path>
  </project>
  <batchBuild/>
</workspace>